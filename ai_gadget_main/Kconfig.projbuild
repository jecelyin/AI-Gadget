## ai_gadget_main/Kconfig.projbuild
```kconfig
menu "Main Board Configuration"

config WEATHER_API_KEY
    string "Weather API Key"
    default ""

endmenu
```
